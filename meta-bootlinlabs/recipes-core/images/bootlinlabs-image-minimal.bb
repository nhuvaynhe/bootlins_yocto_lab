SUMMARY = "This is a small image which specific for game."

IMAGE_INSTALL = "packagegroup-core-bootlins"
inherit core-image

IMAGE_INSTALL += " packagegroup-bootlinlabs-games"
