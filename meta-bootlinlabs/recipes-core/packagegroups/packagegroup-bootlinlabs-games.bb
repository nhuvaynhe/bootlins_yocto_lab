SUMMARY = "Package for game"

inherit packagegroup

RDEPENDS:${PN} = "\
    ninvaders \
    dropbear"

